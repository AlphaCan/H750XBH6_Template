# Keil uVision project H750XBH6_Template.uvprojx, settings and files
target STM32H750XBH6 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.8
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H750XBH6_Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H750xx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: startup_stm32h750xx.s main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart1/: usart1.c usart1.h
